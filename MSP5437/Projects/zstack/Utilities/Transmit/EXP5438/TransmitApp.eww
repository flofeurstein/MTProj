<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TransmitApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TransmitApp</project>
        <configuration>Coordinator</configuration>
      </member>
      <member>
        <project>TransmitApp</project>
        <configuration>Router</configuration>
      </member>
      <member>
        <project>TransmitApp</project>
        <configuration>EndDevice</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


