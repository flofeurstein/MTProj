<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Dongle.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Dongle</project>
        <configuration>EndDevice</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


