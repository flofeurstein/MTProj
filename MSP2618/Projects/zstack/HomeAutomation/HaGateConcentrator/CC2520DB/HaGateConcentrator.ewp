# IAR project HaGateConcentrator.ewp, settings and files
configuration Coordinator (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 512
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP430F2618; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; MT_ZDO_CP_FUNC; MT_HAGATE_FUNC; LCD_SUPPORTED; NV_RESTORE; NV_INIT; ZCL_REPORT
  ICC430.CCDiagSuppress: Pe001,Pe193,Pe236,Pe826
  ICC430.IExtraOptions: -f ..\..\..\Tools\MSP2618\f8wConfig.cfg; -f ..\..\..\Tools\MSP2618\f8wCoord.cfg; -f ..\..\..\Tools\MSP2618\f8wZCL.cfg
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\Source; ..\..\Source; ..\..\..\ZMain\MSP2618; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\MSP2618CC2520; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\dual_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\osal\mcu\msp430; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: ..\..\..\Tools\MSP2618\MSP430F2618.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -C ..\..\..\Libraries\MSP2618\bin\Router2618-Pro.lib; -C ..\..\..\Libraries\MSP2618\bin\Security2618.lib; -C ..\..\..\Libraries\TIMAC\bin\TIMAC-MSP2618.lib
configuration Router (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MSP430F2618; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED
  ICC430.IExtraOptions: -f ..\..\..\Tools\MSP2618\f8wConfig.cfg; -f ..\..\..\Tools\MSP2618\f8wRouter.cfg; -f ..\..\..\Tools\MSP2618\f8wZCL.cfg
configuration EndDevice (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MSP430F2618; NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED
  ICC430.IExtraOptions: -f ..\..\..\Tools\MSP2618\f8wConfig.cfg; -f ..\..\..\Tools\MSP2618\f8wEndev.cfg; -f ..\..\..\Tools\MSP2618\f8wZCL.cfg
  XLINK.XExtraOptions: -C ..\..\..\Libraries\MSP2618\bin\EndDevice2618-Pro.lib; -C ..\..\..\Libraries\MSP2618\bin\Security2618.lib; -C ..\..\..\Libraries\TIMAC\bin\TIMAC-MSP2618.lib
  group Application
    ../Source/: OSAL_HaGateConcentrator.c zcl_HaGateConcentrator.c zcl_HaGateConcentrator.h zcl_HaGateConcentrator_data.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
    ../../../../../Components/hal/include/: hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h
  group HAL/Drivers
    ../../../../../Components/hal/include/: hal_adc.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../../Components/hal/target/MSP2618CC2520/: hal_aes.h
  group HAL/Target/Config
    ../../../../../Components/hal/target/MSP2618CC2520/: DCO_calibrate.h DCO_calibrate.s43 hal_board_cfg.h hal_mac_cfg.c hal_mac_cfg.h hal_startup.c
  group HAL/Target/Drivers
    ../../../../../Components/hal/target/MSP2618CC2520/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/Includes
    ../../../../../Components/hal/target/MSP2618CC2520/: hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/dual_chip/: mac_dualchip.c mac_dualchip.h mac_dualchip_tx.c mac_dualchip_tx.h mac_mcu_timer.c mac_mcu_timer.h mac_radio_defs.c mac_radio_defs.h mac_spi.c mac_spi.h
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_HAGATE.c MT_HAGATE.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/mcu/msp430/: MSP430FlashUtil.c MSP430FlashUtil.h OSAL_Nv.c
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/include/: OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_general.c zcl_general.h
    ../../Source/: zcl_ha.c zcl_ha.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/MSP2618/: f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg MSP430F2618.xcl
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/MSP2618/: OnBoard.c OnBoard.h ZMain.c
